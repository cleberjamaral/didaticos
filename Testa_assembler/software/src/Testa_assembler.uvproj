# Keil uVision project Testa_assembler.uvproj, settings and files
target AT89C55 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: Testa_assembler +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c
